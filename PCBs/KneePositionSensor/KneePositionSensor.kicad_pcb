# Repository craftit/DogBotV4Electronics

File README.md:

# DogBotV4Electronics
Schematics for parts for the latest version of dogbot

## KiCad design PCBs/KneePositionSensor/KneePositionSensor.kicad_pcb

Parts:
C1, C2: 1u; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
G1: LOGO; ReactRoboticsLogo
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x06; Molex_Micro-Latch_53254-0670_1x06_P2.00mm_Horizontal
R1, R2: 100R; R_0603_1608Metric
R3: 330R; R_0603_1608Metric
R4: 1K; R_0603_1608Metric
U1: LP5907MFX-3.3; SOT-23-5
U2: TLE5012BE1000FUMA1; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, U1.5 (OUT), U2.6 (VDD)
+5V: C1.1, J1.6, U1.1 (IN), U1.3 (EN)
GND: C1.2, C2.2, D1.1 (K), J1.1, U1.2 (GND), U2.7 (GND)
unnamed: D1.2 (A), R4.1
unnamed: J1.2, R3.2
unnamed: J1.3, R4.2
unnamed: J1.4, R2.2
unnamed: J1.5, R1.2
unnamed: R1.1, U2.3 (CSQ)
unnamed: R2.1, U2.2 (SCK)
unnamed: R3.1, U2.4 (DATA)

Notes on the sheet:
Brown
Pink
Green
Yellow
Blue
Grey

Board: 2 copper layers, 33.3 x 32.7 mm, 14 parts (2 on the bottom side), 11 nets.

## KiCad design PCBs/LegSensorBoard/LegSensorBoard.kicad_pcb

Parts:
C1, C2, C3: 1u; C_0805_2012Metric
C4, C6, C8, C9, C11, C12, C13, C14, C15, C22: 100n; C_0603_1608Metric
C5, C7: 15p; C_0603_1608Metric
C10: 4u7; C_0805_2012Metric
D1: DB2W60400L; D_SOD-123F
D2: LED GREEN; LED_0805_2012Metric
D3: LED RED; LED_0805_2012Metric
G1: LOGO; ReactRoboticsLogo
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: CanIO; Molex_Micro-Latch_53253-0470_1x04_P2.00mm_Vertical
J3: USB_B_Micro; USB_Mini-B_Lumberg_2486_01_Horizontal
J4: GeneralIO; PinHeader_1x10_P2.54mm_Vertical
J5: UART; Molex_Micro-Latch_53253-0570_1x05_P2.00mm_Vertical
J6: TC2030-MCP-NL; Tag-Connect_TC2030-IDC-FP_2x03_P1.27mm_Vertical
J7: Encoder2; Molex_Micro-Latch_53253-0770_1x07_P2.00mm_Vertical
J8: Encoder1; Molex_Micro-Latch_53254-0770_1x07_P2.00mm_Horizontal
R1, R2: 22R; R_0603_1608Metric
R3: 120R; R_0603_1608Metric
R4, R5: 1K; R_0603_1608Metric
R6, R7: 10K; R_0603_1608Metric
R8: 1K5; R_0603_1608Metric
SW1, SW2: SW_SPST; SW_SPST_FSMSM
TP1: +5V; TestPoint_Pad_2.0x2.0mm
TP2: GND; TestPoint_Pad_4.0x4.0mm
TP3: SPI2_MISO; TestPoint_Pad_2.0x2.0mm
TP4: SPI2_MOSI; TestPoint_Pad_2.0x2.0mm
TP5: SPI2_CLK; TestPoint_Pad_2.0x2.0mm
TP6: NSEL_ACC; TestPoint_Pad_2.0x2.0mm
TP7: CAN_TX; TestPoint_Pad_2.0x2.0mm
TP8: 3.3V; TestPoint_Pad_2.0x2.0mm
TP9: CAN_RX; TestPoint_Pad_2.0x2.0mm
TP10: INT1; TestPoint_Pad_2.0x2.0mm
TP11: INT2; TestPoint_Pad_2.0x2.0mm
TP12: ADC_CS; TestPoint_Pad_2.0x2.0mm
U1: LP5907MFX-3.3; SOT-23-5
U2: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U3: LSM6DS3; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U4: STM32F302CCT6; LQFP-48_7x7mm_P0.5mm
Y1: ABM3-8.000MHZ-B4Y-T; Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm

Connections:
+3V3: C2.1, C4.1, C6.1, C10.1, C11.1, C12.1, C13.1, C15.1, C22.1, J6.1, TP8.1, U1.5 (OUT), U2.5 (VIO), U3.5 (VDDIO), U3.8 (VDD), U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD); also elsewhere on the board
+5V: C1.1, C3.1, D1.1 (K), J1.2, J2.2, J4.9, J5.4, J7.6, J8.6, R6.1, TP1.1, U1.1 (IN), U1.3 (EN), U2.3 (VCC); also elsewhere on the board
/StrainGauge/GPIO: J4.4; also elsewhere on the board
ACCEL_INT1: TP10.1, U3.4 (INT1), U4.19 (PB1)
ACCEL_INT2: TP11.1, U3.9 (INT2), U4.18 (PB0)
ADC_DRDY: U4.20 (PB2); also elsewhere on the board
CAN_STB: U2.8 (STB), U4.40 (PB4)
CLK_8MHZ: U4.29 (PA8); also elsewhere on the board
CanRx: TP9.1, U2.4 (RXD), U4.45 (PB8)
CanTx: TP7.1, U2.1 (TXD), U4.46 (PB9)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C22.2, D2.1 (K), D3.1 (K), J1.1, J2.1, J3.5 (GND), J3.6 (Shield), J4.1, J4.10, J5.1, J5.5, J6.3, J7.1, J7.7, J8.1, J8.7, R7.2, SW1.2 (B), SW2.2 (B), TP2.1, U1.2 (GND), U2.2 (GND), U3.2 (SDX), U3.3 (SCX), U3.6 (GND), U3.7 (GND), U4.8 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.44 (BOOT0), U4.47 (VSS); also elsewhere on the board
NENCODER2: J7.5, U4.13 (PA3)
NRESET: C9.1, J6.5, SW1.1 (A), U4.7 (NRST); also elsewhere on the board
unnamed: C5.1, U4.5 (PF0), Y1.2
unnamed: C7.1, U4.6 (PF1), Y1.1
unnamed: C8.1, SW2.1 (A), U4.4 (PC15)
unnamed: C14.1, R6.2, R7.1, U4.10 (PA0)
unnamed: D1.2 (A), J3.1 (VBUS)
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: J1.3, J2.3, R3.2, U2.7 (CANH)
unnamed: J1.4, J2.4, R3.1, U2.6 (CANL)
unnamed: J3.2 (D-), R2.1
unnamed: J3.3 (D+), R1.1, R8.2
unnamed: R4.1, U4.2 (PC13)
unnamed: R5.1, U4.3 (PC14)
PA1: J4.2, U4.11 (PA1)
PA2: J4.3, U4.12 (PA2)
PB5: R8.1, U4.41 (PB5)
PB6: J4.5, U4.42 (PB6)
PB7: J4.6, U4.43 (PB7)
PB10: J4.7, U4.21 (PB10)
PB11: J4.8, U4.22 (PB11)
SPI1_CLK: J7.4, J8.4, U4.15 (PA5)
SPI1_MISO: J7.3, J8.3, U4.16 (PA6)
SPI1_MOSI: J7.2, J8.2, U4.17 (PA7)
SPI1_NSS: J8.5, U4.14 (PA4)
SPI2_ADC_CS: TP12.1, U4.38 (PA15); also elsewhere on the board
SPI2_CLK: TP5.1, U3.13 (SCL), U4.26 (PB13); also elsewhere on the board
SPI2_MISO: TP3.1, U3.1 (SDO/SA0), U4.27 (PB14); also elsewhere on the board
SPI2_MOSI: TP4.1, U3.14 (SDA), U4.28 (PB15); also elsewhere on the board
SPI2_NSS: TP6.1, U3.12 (CS), U4.25 (PB12)
SWCLK: J6.2, U4.37 (PA14)
SWDIO: J6.4, U4.34 (PA13)
SWO: J6.6, U4.39 (PB3)
UART_RX: J5.3, U4.31 (PA10)
UART_TX: J5.2, U4.30 (PA9)
USB_DM: R2.2, U4.32 (PA11)
USB_DP: R1.2, U4.33 (PA12)

Notes on the sheet:
Brown
Pink
Green
Yellow
Blue
Grey
Screen

Parts:
C16, C17, C18, C19, C20, C21: 1n; C_0603_1608Metric
C23: 220n; C_0603_1608Metric
C24: 1n C0G; C_0603_1608Metric
C26: 1u; C_0805_2012Metric
J9: STRAIN1; Molex_Micro-Latch_53254-0770_1x07_P2.00mm_Horizontal
J10: STRAIN2; Molex_Micro-Latch_53253-0770_1x07_P2.00mm_Vertical
J11: STRAIN3; Molex_Micro-Latch_53253-0770_1x07_P2.00mm_Vertical
TP13: ADC_RDY; TestPoint_Pad_2.0x2.0mm
TP14: CLK_8MHZ; TestPoint_Pad_2.0x2.0mm
TP16: +3.3VA; TestPoint_Pad_2.0x2.0mm
U5: MAX11254ATJ+T; QFN50P500X500X80-33N
U6: LP5907MFX-3.3; SOT-23-5

Connections:
+3.3VA: C26.1, J9.2, J10.2, J11.2, TP16.1, U5.3 (AVDD), U5.5 (REFP), U6.5 (OUT)
+3V3: U5.28 (DVDD); also elsewhere on the board
+5V: U6.1 (IN), U6.3 (EN); also elsewhere on the board
/StrainGauge/GPIO: U5.25 (GPIO1/SYNC); also elsewhere on the board
ADC_DRDY: TP13.1, U5.1 (RDYB); also elsewhere on the board
CLK_8MHZ: TP14.1, U5.23 (GPIOO/CLK); also elsewhere on the board
GND: C23.2, C26.2, J9.1, J10.1, J11.1, J11.7, U5.4 (AVSS), U5.6 (REFN), U5.21 (GPOGND), U5.29 (DGND), U5.33 (EP), U6.2 (GND); also elsewhere on the board
NRESET: U5.27 (RSTB); also elsewhere on the board
unnamed: C16.1, J11.5, U5.18 (AIN5P)
unnamed: C16.2, J11.6, U5.17 (AIN5N)
unnamed: C17.1, J10.3, U5.12 (AIN2P)
unnamed: C17.2, J10.4, U5.11 (AIN2N)
unnamed: C18.1, J10.5, U5.14 (AIN3P)
unnamed: C18.2, J10.6, U5.13 (AIN3N)
unnamed: C19.1, J11.3, U5.16 (AIN4P)
unnamed: C19.2, J11.4, U5.15 (AIN4N)
unnamed: C20.1, J9.5, U5.10 (AIN1P)
unnamed: C20.2, J9.6, U5.9 (AIN1N)
unnamed: C21.1, J9.3, U5.7 (AINON)
unnamed: C21.2, J9.4, U5.8 (AINOP)
unnamed: C23.1, U5.26 (CAPREG)
unnamed: C24.1, U5.19 (CAPN)
unnamed: C24.2, U5.20 (CAPP)
unnamed: J9.7, U5.24 (GPOO)
unnamed: J10.7, U5.22 (GPO1)
SPI2_ADC_CS: U5.31 (CSB); also elsewhere on the board
SPI2_CLK: U5.2 (SCLK); also elsewhere on the board
SPI2_MISO: U5.30 (DOUT); also elsewhere on the board
SPI2_MOSI: U5.32 (DIN); also elsewhere on the board

Notes on the sheet:
FixMe: Should move AIN0 to top.

Board: 4 copper layers, 68.0 x 42.0 mm, 76 parts (1 on the bottom side), 67 nets.

## KiCad design PCBs/AngleSensorBoard/AngleSensorBoard.kicad_pcb

Parts:
C1: 100n; C_0805_2012Metric
C2: 1uF; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
G1: LOGO
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Temp; Molex_Micro-Latch_53254-0270_1x02_P2.00mm_Horizontal
J2: Controller; Molex_Micro-Latch_53254-0770_1x07_P2.00mm_Horizontal
J3: Index; Molex_Micro-Latch_53254-0370_1x03_P2.00mm_Horizontal
R1: 10K; R_0805_2012Metric
R2: 1K; R_0805_2012Metric
U1: TLE5012BE1000FUMA1; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, J2.6, J3.3, R1.1, U1.6 (VDD)
/HallA: C1.1, J1.2, J2.4, R1.2
/HallB: J2.3, U1.3 (CSQ)
/HallC: J2.2, J3.1, R2.1
/Index: J2.5, U1.2 (SCK)
/Temp: J2.1, U1.4 (DATA)
GND: C1.2, C2.2, D1.1 (K), J1.1, J2.7, J3.2, U1.7 (GND)
unnamed: D1.2 (A), R2.2

Notes on the sheet:
White
Grey
Blue
Green
Yellow
Pink
Brown

Board: 2 copper layers, 34.0 x 34.0 mm, 14 parts (2 on the bottom side), 8 nets.

## Code that names these connections

File PCBs/LegSensorBoard/LegSensor.ioc (part):

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Mcu.Name=STM32F302C(B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F302CCTx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.Signal=GPIO_Output
PA3.Signal=GPIO_Output
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Mode=Clock-out
PA8.Signal=RCC_MCO
PB0.Signal=GPIO_Input
PB1.Signal=GPIO_Input
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB4.Signal=GPIO_Output
PB5.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.Mode=Master
PB8.Signal=CAN_RX
PB9.Mode=Master
PB9.Signal=CAN_TX
PC13.Signal=GPIO_Output
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.GPIOParameters=GPIO_PuPd
PC15-OSC32_OUT.GPIO_PuPd=GPIO_PULLUP
PC15-OSC32_OUT.Signal=GPIO_Input
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2021-01-16 Leg sensor boards.

Notices in the files:
PCBs/KneePositionSensor/KneePositionSensor.kicad_pcb:
©2019 ReactAI Ltd
